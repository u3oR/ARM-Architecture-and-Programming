# Keil uVision project stm32-project.uvprojx, settings and files
target stm32-project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: stm32-project +hex
  AfterMake: fromelf --bin --output=stm32-project\stm32-project.bin stm32-project\stm32-project.axf
  AfterMake: fromelf --text -a -c --output=stm32-project\stm32-project.dis stm32-project\stm32-project.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\UserApp
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: ./stm32-project.sct
  group MDK-ARM
    ./: startup_stm32f103xe.s
  group Application
    ../UserApp/: main.c
  group Application/lib
    ../UserApp/: gpio.c my_string.c uart.c
software components: CMSIS:CORE 5.6.0
